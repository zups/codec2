## zephyr/Kconfig
```kconfig
config CODEC2_MODULE
	bool "codec2 module support"
	help
	  This option builds the codec2 module.
```
